options:
  parameters:
    author: pentester
    generate_options: qt_gui
    id: sniffer_11_12
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channels
  id: variable
  parameters:
    value: '[frequency]'
  states: {}
- name: decode_downlink
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    type: intx
    value: '125000'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: '867.1'
    freq: +900e3
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    comment: '867.3'
    freq: +700e3
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0_0
  id: blocks_freqshift_cc
  parameters:
    comment: '867.5'
    freq: +500e3
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0_0_0
  id: blocks_freqshift_cc
  parameters:
    comment: '867.7'
    freq: +300e3
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0_0_0_0
  id: blocks_freqshift_cc
  parameters:
    comment: '868.0'
    freq: '0'
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0_0_0_1
  id: blocks_freqshift_cc
  parameters:
    comment: '867.9'
    freq: +100e3
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0_0_0_1_0
  id: blocks_freqshift_cc
  parameters:
    comment: '868.1'
    freq: '-100e3'
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0_0_0_2
  id: blocks_freqshift_cc
  parameters:
    comment: '868.3'
    freq: '-300e3'
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0_0_1
  id: blocks_freqshift_cc
  parameters:
    comment: '868.5'
    freq: '-500e3'
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0_1
  id: blocks_freqshift_cc
  parameters:
    comment: '868.7'
    freq: '-700e3'
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_1
  id: blocks_freqshift_cc
  parameters:
    comment: '868.9'
    freq: '-900e3'
    sample_rate: samp_rate
  states: {state: disabled}
- name: frequency
  id: parameter
  parameters:
    type: eng_float
    value: 868.3e6
  states: {}
- name: gain_db
  id: parameter
  parameters:
    type: intx
    value: '10'
  states: {}
- name: lora_message_socket_sink_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '0'
    port: '40868'
  states: {}
- name: lora_rx_1
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '0'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '11'
    soft_decoding: 'False'
  states: {state: disabled}
- name: lora_rx_1_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '12'
    soft_decoding: 'True'
  states: {state: disabled}
- name: lora_rx_1_1_1_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: spreading_factor
    soft_decoding: 'False'
  states: {state: disabled}
- name: lora_rx_1_1_1_0_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: spreading_factor
    soft_decoding: 'False'
  states: {state: disabled}
- name: lora_rx_1_1_1_0_0_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: spreading_factor
    soft_decoding: 'True'
  states: {}
- name: lora_rx_1_1_1_0_0_1
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: spreading_factor
    soft_decoding: 'False'
  states: {state: disabled}
- name: lora_rx_1_1_1_0_0_2
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: spreading_factor
    soft_decoding: 'False'
  states: {state: disabled}
- name: lora_rx_1_1_1_0_0_3
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: spreading_factor
    soft_decoding: 'False'
  states: {state: disabled}
- name: lora_rx_1_1_1_0_1
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: spreading_factor
    soft_decoding: 'False'
  states: {state: disabled}
- name: lora_rx_1_1_1_0_2
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: spreading_factor
    soft_decoding: 'False'
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '2000000'
  states: {}
- name: spreading_factor
  id: parameter
  parameters:
    type: intx
    value: '7'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: frequency
    gain0: gain_db
    minoutbuf: '100000'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [lora_rx_1_1_1_0_0_0, out, lora_message_socket_sink_0, in]
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0_1_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0_2, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_1, '0']
- [uhd_usrp_source_0, '0', lora_rx_1_1_1_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_0_0, '0']

metadata:
  file_format: 1
