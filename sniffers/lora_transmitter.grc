options:
  parameters:
    author: konicst1
    generate_options: qt_gui
    id: LoRaTransmitter
    output_language: python
    title: LoRaTransmitter
  states: {}

blocks:
- name: byte_data
  id: variable
  parameters:
    value: bytes.fromhex(message)
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    type: intx
    value: '125000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.init_u8vector(len(byte_data), list(byte_data))
    period: '1000'
  states: {state: disabled}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern(byte_data)
    period: '1000'
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: eng_float
    value: 868.1e6
  states: {}
- name: gain_db
  id: parameter
  parameters:
    type: intx
    value: '10'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: bandwidth
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '2'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {}
- name: message
  id: parameter
  parameters:
    type: str
    value: 48656c6cffff776f726c64
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '1000000'
  states: {}
- name: spreading_factor
  id: parameter
  parameters:
    type: intx
    value: '7'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: frequency
    gain0: gain_db
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_0, strobe, lora_tx_0, in]
- [blocks_message_strobe_1, strobe, lora_tx_0, in]
- [lora_tx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
